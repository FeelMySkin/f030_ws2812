# Keil uVision project ws2812.uvprojx, settings and files
target ws2812 (ARM-ADS)
  output: ws2812
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .eide\deps
  library: MicroLIB
  memory RVCT1: RAM 0x08000000 size 0x10000
  memory RVCT6: RAM 0x20000000 size 0x5000
